Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-04-16T12:43:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 16 12:43:44 2021 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{CCF859D3-11B8-4F20-B054-88CA19D428C4}\ifc * Database version: 5507 * Database creation date: Fri Apr 16 12:43:43 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 16 12:43:43 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 16 12:43:43 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: Brushed Stainless Steel, Duten_HndDriers_M495:Brushed Stainless Steel:324636
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_BrushedStainlessSteel
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Brushed Stainless Steel; Manufacturer: Duten

# IfcBuildingElementProxy: Matte Black, Duten_HndDriers_M495:Matte Black:324621
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_MatteBlack
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Matte Black; Manufacturer: Duten

# IfcBuildingElementProxy: Polished Brass, Duten_HndDriers_M495:Polished Brass:322389
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_Polished
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Polished Brass; Manufacturer: Duten
